# Keil uVision project 123.uvproj, settings and files
target 202313141300412 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 123 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: main.c
  group Driver
    ../Driver/: Init.c Init.h Key.c Key.h Led.c Led.h Seg.c Seg.h ds1302.c ds1302.h iic.c iic.h onewire.c onewire.h ultrasound.c ultrasound.h Uart.c Uart.h
