# Keil uVision project 202313141300412.uvproj, settings and files
target 202313141300412 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 202313141300412 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver;..\Driver
  asm include: ..\Driver
  group User
    ./: main.c
  group Driver
    ../Driver/: ds1302.c onewire.c ds1302.h onewire.h Seg.c Seg.h Init.c Init.h Key.c Key.h Led.c Led.h
