# Keil uVision project 大模板.uvproj, settings and files
target 大模板 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 大模板 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Drive
  asm include: ..\Drive
  group User
    ./: main.c
  group Drive
    ../Drive/: iic.c iic.h ds1302.c ds1302.h Init.c Init.h Key.c Key.h Led.c Led.h onewire.c onewire.h Seg.c Seg.h ultrasound.c ultrasound.h
