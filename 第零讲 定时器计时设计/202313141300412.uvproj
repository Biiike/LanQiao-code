# Keil uVision project 202313141300412.uvproj, settings and files
target 202313141300412 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 202313141300412 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Drive
  group User
    ./User/: main.c
  group Drive
    ./Drive/: Key.c Key.h Seg.c Seg.h
